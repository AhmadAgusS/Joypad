# Keil uVision project lark_dvb_watch.uvprojx, settings and files
target SensorAlgoHR (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: hr_gh30x
  AfterMake: UserCommand.bat "!L" "$K\ARM"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Inc;..\GH3011_Port
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x10000
  scatter file: lark_ac5.sct
  link misc: --datacompressor=off --no_startup --entry hr_algo_init --keep=hr_algo.o(*) --keep=hr_algo_data.o(*)
  group Libraries/HR
    ../GH3011_Lib/: hbd_communicate_KEIL5_M4-fp.lib hbd_ctrl_KEIL5_M4-fp.lib
  group Porting/HR
    ../GH3011_Port/: gh3011_example_comm_pkg.c gh3011_example_ctrl.c gh3011_example_process.c gh3011_example_reg_array.c
  group Examples/User
    ../Src/: hr_algo.c hr_algo_data.c gh3011_port.c
