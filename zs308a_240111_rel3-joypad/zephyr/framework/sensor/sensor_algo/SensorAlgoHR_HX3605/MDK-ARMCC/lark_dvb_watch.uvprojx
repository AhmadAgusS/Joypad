# Keil uVision project lark_dvb_watch.uvprojx, settings and files
target SensorAlgoHR (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: hr_hx3605
  AfterMake: UserCommand.bat "!L" "$K\ARM"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Inc;..\HX3605_Port
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x10000
  scatter file: lark_ac5.sct
  link misc: --datacompressor=off --no_startup --entry hr_algo_init --keep=hr_algo.o(*) --keep=hr_algo_data.o(*)
  group Libraries/HR
    ../HX3605_Lib/: m4f_3605_keil_biglib_hrs_spo2_hrv_20220812.lib
  group Porting/HR
    ../HX3605_Port/: hx3605.c hx3605_factory_test.c hx3605_hrs_agc.c hx3605_spo2_agc.c
  group Examples/User
    ../Src/: hr_algo.c hr_algo_data.c
