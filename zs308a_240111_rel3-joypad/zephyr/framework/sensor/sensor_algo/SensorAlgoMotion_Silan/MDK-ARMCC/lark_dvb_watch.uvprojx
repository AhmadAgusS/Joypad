# Keil uVision project lark_dvb_watch.uvprojx, settings and files
target SensorAlgoMotion (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.7.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: motion_silan
  AfterMake: UserCommand.bat "!L" "$K\ARM"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c misc: --diag_suppress=188
  c include: ..\Inc;..\Silan_Inc
  library: MicroLIB
  memory RVCT4: ROM 0x10000000 size 0x100000
  memory RVCT9: RAM 0x100000 size 0x10000
  scatter file: lark_ac5.sct
  link misc: --datacompressor=off --no_startup --entry sensor_algo_init --keep=sensor_algo.o(*) --keep=sensor_algo_data.o(*)
  group Libraries/Silan
    ../Silan_Lib/: SL_Watch_Pedo_Kcal_Wrist_Sleep_Sway_Algorithm.lib
  group Examples/User
    ../Src/: sensor_algo.c sensor_algo_data.c sensor_port.c SL_Watch_Pedo_Kcal_Wrist_Sleep_Sway_Application.c
